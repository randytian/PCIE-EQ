# Keil uVision project PEMCU_T1.uvproj, settings and files
target PEMCU (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: PEMCU_Fw +hex
  AfterMake: BinFileHandle.bat
  c flags: Optimize=8 SizeSpeed=1
  group Global
    ./: STARTUP.A51
    ./Src/: EQ.c Eye_monitor.c main.c timer.c trace.c uart.c Eye_monitor2.c Eye_monitor3.c
